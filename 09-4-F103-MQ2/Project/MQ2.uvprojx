# Keil uVision project MQ2.uvprojx, settings and files
target test (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Fire_F103C8
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Drivers\CMSIS;..\Drivers\STM32F10x_StdPeriph_Driver\inc;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Drivers/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Drivers/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Drivers/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c
    ../User/usart/: bsp_usart.c
    ../User/mq2/: bsp_mq2.c
  group DOC
    ../Doc/: readme.txt
  group MODBUS-SLAVE
    ../User/modbus_slave/: application_data_manager.c modbus_slave_protocol.c modbus_rtu_link.c modbus_crc.c tim4_tick_driver.c usart2_rs485_driver.c
